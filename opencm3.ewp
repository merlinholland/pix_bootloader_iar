# IAR project opencm3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100C8 ST STM32F100C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F1
  ICCARM.CCIncludePath2: inc; libopencm3\include\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: opencm3.bin
  ILINK.IlinkOutputFile: opencm3.out
  ILINK.IlinkIcfFile: opencm3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    libopencm3/include/libopencmsis/: core_cm3.h
  group libopencm3/lib/cm3
    libopencm3/lib/cm3/: assert.c dwt.c nvic.c scb.c systick.c vector.c
  group libopencm3/lib/stm32/common
    libopencm3/lib/stm32/common/: flash_common_f01.c gpio_common_all.c rcc_common_all.c usart_common_all.c usart_common_f124.c
  group libopencm3/lib/stm32/f1
    libopencm3/lib/stm32/f1/: flash.c gpio.c rcc.c usart.c vector_nvic.c
  group src
    src/: bl.c main.c usr_usart.c
